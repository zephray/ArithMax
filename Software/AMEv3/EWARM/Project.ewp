# IAR project Project.ewp, settings and files
configuration STM32100B-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\; ..\CMSIS; ..\StdPeriph_Driver\inc; ..\Eigenmath; ..\GUI
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f40x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c
  group eigenmath
    ../Eigenmath/: aboutGUI.cpp abs.cpp add.cpp adj.cpp alloc.cpp append.cpp arccos.cpp arccosh.cpp arcsin.cpp arcsinh.cpp arctan.cpp arctanh.cpp arg.cpp atomize.cpp bake.cpp bignum.cpp binomial.cpp ceiling.cpp choose.cpp circexp.cpp clear.cpp clock.cpp coeff.cpp cofactor.cpp condense.cpp conj.cpp cons.cpp contract.cpp cos.cpp cosh.cpp data.cpp dConsole.cpp decomp.cpp define.cpp defint.cpp degree.cpp denominator.cpp derivative.cpp det.cpp dirac.cpp distill.cpp divisors.cpp dpow.cpp dsolve.cpp eigen.cpp emain.cpp erf.cpp erfc.cpp eval.cpp expand.cpp expcos.cpp expsin.cpp factor.cpp factorial.cpp factorpoly.cpp factors.cpp filter.cpp find.cpp float.cpp floor.cpp for.cpp gamma.cpp gcd.cpp guess.cpp hermite.cpp hilbert.cpp history.cpp imag.cpp index.cpp init.cpp inner.cpp integral.cpp inv.cpp is.cpp isprime.cpp itab.cpp itest.cpp laguerre.cpp laplace.cpp lcm.cpp leading.cpp legendre.cpp list.cpp log.cpp madd.cpp mag.cpp mcmp.cpp mfactor.cpp mgcd.cpp mini-test.cpp misce.cpp mmodpow.cpp mmul.cpp mod.cpp mpow.cpp mprime.cpp mroot.cpp mscan.cpp msqrt.cpp mstr.cpp multiply.cpp nroots.cpp numerator.cpp outer.cpp partition.cpp polar.cpp pollard.cpp power.cpp prime.cpp primetab.cpp print.cpp product.cpp qadd.cpp qdiv.cpp qmul.cpp qpow.cpp qsub.cpp quickfactor.cpp quotient.cpp rationalize.cpp real.cpp rect.cpp rewrite.cpp roots.cpp run.cpp scan.cpp selftest.cpp sgn.cpp simfac.cpp simplify.cpp sin.cpp sinh.cpp stack.cpp subst.cpp sum.cpp symbol.cpp tan.cpp tanh.cpp taylor.cpp tensor.cpp test.cpp transform.cpp transpose.cpp userfunc.cpp variables.cpp vectorize.cpp versionProvider.cpp zero.cpp
  group Startup
    ../Startup/: startup_stm32f2xx.s
  group StdPeriph_Driver
    ../StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../: g2048.c key.c main.c pccon.c powerman.c rtc.c sdcard.c spiflash.c stm32f4xx_it.c stn.c usart.c image-font-8.c
